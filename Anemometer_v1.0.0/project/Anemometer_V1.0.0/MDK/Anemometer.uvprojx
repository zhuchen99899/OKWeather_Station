# Keil uVision project Anemometer.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Anemometer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx, __free_rtos__
  c include: ..\user\config;..\..\..\elab\3rd\Shell;..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\..\..\mcu\stm32g070\STM32G070;..\..\..\mcu\stm32g070\CMSIS;..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc\Legacy;..\..\..\elab\3rd\FreeRTOS\include;..\..\..\elab\3rd\FreeRTOS\portable\RVDS\ARM_CM0;..\user;..\..\..\..\Anemometer_v1.0.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group eLab.common
    ../../../elab/common/: elab_assert.c elab_common.c elab_export.c elab_log.c
  group eLab.edf
    ../../../elab/edf/: elab_device.c elab_device_null.c
    ../../../elab/edf/normal/: elab_pin.c elab_spi.c
    ../../../elab/edf/user/: elab_led.c
  group eLab.elib
    ../../../elab/elib/: elib_queue.c
  group eLab.3rd.Shell
    ../../../elab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group eLab.3rd.FreeRTOS
    ../../../elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../elab/3rd/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../elab/3rd/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../../../elab/os/mcu/: cmsis_os2.c
  group MCU
    ../../../mcu/stm32g070/STM32G070/: stm32g0xx_it.c system_stm32g0xx.c
    ../../../mcu/stm32g070/STM32G070/arm/: startup_stm32g070xx.s
  group MCU.HAL
    ../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_wwdg.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c
  group User.Bsp
    ../user/bsp/: bsp.c elab_uart_debug.c
  group User.Driver
    ../user/driver/: drv_pin_mcu.c drv_util.c drv_spi_bus.c
  group User.Device
    ../user/device/: elab_ms1022.c elab_74hc4052d.c elab_anemometer.c
  group User.Export
    ../user/export/: shell_export.c led_export.c pin_export.c spi_export.c
  group User.Config
    ../user/config/: elab_config.h FreeRTOSConfig.h gb_export.h stm32g0xx_hal_conf.h
  group User.App
    ../user/: main.c
  group User.Test
    ../user/test/: system_test.c ms1022_test.c
